## boards/raspberrypi/rr/board.yml
```yaml
board:
  name: rr
  full_name: RossRobotics
  vendor: rossrobotics
  socs:
  - name: rp2040
    variants:
    - name: w
```
